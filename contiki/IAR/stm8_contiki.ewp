# IAR project stm8_contiki.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_HD
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\platform\STM8L15x_StdPeriph_Driver\inc; ..\platform\User; ..\contiki; ..\contiki\core; ..\contiki\core\sys; ..\contiki\core\lib; ..\contiki\cpu\stm8l151c8
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_contiki.hex
  ILINK.IlinkOutputFile: stm8_contiki.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group contiki
    ../contiki/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group contiki/core/sys
    ../contiki/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
  group contiki/cpu/stm8l151c8
    ../contiki/cpu/stm8l151c8/: clock.c debug-uart.c spi.c
  group platform/Stdperiph_Driver
    ../platform/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim2.c stm8l15x_usart.c stm8l15x_wwdg.c
  group platform/User
    ../platform/User/: contiki-conf.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
